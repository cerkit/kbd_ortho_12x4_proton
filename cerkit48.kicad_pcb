# Repository cerkit/kbd_ortho_12x4_proton

File README.md:

# kbd_ortho_12x4_proton (cerkit48)
 12x4 Ortholinear with integrated [Proton C](https://qmk.fm/proton-c/)

 This is my second keyboard design. After finishing my [first design](https://github.com/cerkit/kbd_ortho_12x4), I decided to integrate the [microcontroller](https://qmk.fm/proton-c/) into the board to reduce the amount of wires everywhere and make it more complete.

 This hasn't been tested.

It has a pin header for I2C integration at the top of the board. It's connected to the I2C1 pins on B8 and B9 of the Proton.

Here are the pin connections:

* Row 0: B13
* Row 1: B14
* Row 2: B15
* Row 3: B10
* Col 0: B7
* Col 1: B6
* Col 2: B5
* Col 3: B4
* Col 4: B3
* Col 5: B2
* Col 6: B1
* Col 7: B0
* Col 8: A6
* Col 9: A7
* Col 10: A8
* Col 11: A15

I've created the board firmware as [cerkit48 in my GitHub branch for qmk_firmware](https://github.com/cerkit/qmk_firmware)

Make example for this keyboard (after setting up your build environment):

    make cerkit48:default
    
The copper fill is the ground plane.

Special thanks to [@tzarc](https://github.com/tzarc), [D3vastat0r](https://github.com/covah901), and [zvecr](https://github.com/zvecr) for answering my questions on the QMK Discord.

## KiCad design cerkit48.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: I2C; PIN_HEADER_I2C
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48: CherryMX; MXOnly-1U-NoLED
U1: proton_c; proton_c_no_center_pins

Connections:
3.3V: J1.2, U1.3.3V (VCC/3.3v)
COL0: SW1.1 (COL), SW13.1 (COL), SW25.1 (COL), SW37.1 (COL), U1.B7 (PB7/SDA)
COL1: SW2.1 (COL), SW14.1 (COL), SW26.1 (COL), SW38.1 (COL), U1.B6 (PB6/SCL)
COL2: SW3.1 (COL), SW15.1 (COL), SW27.1 (COL), SW39.1 (COL), U1.B5
COL3: SW4.1 (COL), SW16.1 (COL), SW28.1 (COL), SW40.1 (COL), U1.B4
COL4: SW5.1 (COL), SW17.1 (COL), SW29.1 (COL), SW41.1 (COL), U1.B3
COL5: SW6.1 (COL), SW18.1 (COL), SW30.1 (COL), SW42.1 (COL), U1.B2
COL6: SW7.1 (COL), SW19.1 (COL), SW31.1 (COL), SW43.1 (COL), U1.B1
COL7: SW8.1 (COL), SW20.1 (COL), SW32.1 (COL), SW44.1 (COL), U1.B0
COL8: SW9.1 (COL), SW21.1 (COL), SW33.1 (COL), SW45.1 (COL), U1.A6
COL9: SW10.1 (COL), SW22.1 (COL), SW34.1 (COL), SW46.1 (COL), U1.A7
COL10: SW11.1 (COL), SW23.1 (COL), SW35.1 (COL), SW47.1 (COL), U1.A8
COL11: SW12.1 (COL), SW24.1 (COL), SW36.1 (COL), SW48.1 (COL), U1.A15
GND: J1.1, U1.GND
unnamed: D1.2 (A), SW1.2 (ROW)
unnamed: D2.2 (A), SW2.2 (ROW)
unnamed: D3.2 (A), SW3.2 (ROW)
unnamed: D4.2 (A), SW4.2 (ROW)
unnamed: D5.2 (A), SW5.2 (ROW)
unnamed: D6.2 (A), SW6.2 (ROW)
unnamed: D7.2 (A), SW7.2 (ROW)
unnamed: D8.2 (A), SW8.2 (ROW)
unnamed: D9.2 (A), SW9.2 (ROW)
unnamed: D10.2 (A), SW10.2 (ROW)
unnamed: D11.2 (A), SW11.2 (ROW)
unnamed: D12.2 (A), SW12.2 (ROW)
unnamed: D13.2 (A), SW13.2 (ROW)
unnamed: D14.2 (A), SW14.2 (ROW)
unnamed: D15.2 (A), SW15.2 (ROW)
unnamed: D16.2 (A), SW16.2 (ROW)
unnamed: D17.2 (A), SW17.2 (ROW)
unnamed: D18.2 (A), SW18.2 (ROW)
unnamed: D19.2 (A), SW19.2 (ROW)
unnamed: D20.2 (A), SW20.2 (ROW)
unnamed: D21.2 (A), SW21.2 (ROW)
unnamed: D22.2 (A), SW22.2 (ROW)
unnamed: D23.2 (A), SW23.2 (ROW)
unnamed: D24.2 (A), SW24.2 (ROW)
unnamed: D25.2 (A), SW25.2 (ROW)
unnamed: D26.2 (A), SW26.2 (ROW)
unnamed: D27.2 (A), SW27.2 (ROW)
unnamed: D28.2 (A), SW28.2 (ROW)
unnamed: D29.2 (A), SW29.2 (ROW)
unnamed: D30.2 (A), SW30.2 (ROW)
unnamed: D31.2 (A), SW31.2 (ROW)
unnamed: D32.2 (A), SW32.2 (ROW)
unnamed: D33.2 (A), SW33.2 (ROW)
unnamed: D34.2 (A), SW34.2 (ROW)
unnamed: D35.2 (A), SW35.2 (ROW)
unnamed: D36.2 (A), SW36.2 (ROW)
unnamed: D37.2 (A), SW37.2 (ROW)
unnamed: D38.2 (A), SW38.2 (ROW)
unnamed: D39.2 (A), SW39.2 (ROW)
unnamed: D40.2 (A), SW40.2 (ROW)
unnamed: D41.2 (A), SW41.2 (ROW)
unnamed: D42.2 (A), SW42.2 (ROW)
unnamed: D43.2 (A), SW43.2 (ROW)
unnamed: D44.2 (A), SW44.2 (ROW)
unnamed: D45.2 (A), SW45.2 (ROW)
unnamed: D46.2 (A), SW46.2 (ROW)
unnamed: D47.2 (A), SW47.2 (ROW)
unnamed: D48.2 (A), SW48.2 (ROW)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.B13 (PB13/SCLK)
ROW1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.B14 (PB14/MISO)
ROW2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.B15 (PB15/MOSI)
ROW3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U1.B10
SCL: J1.4, U1.B8
SDA: J1.3, U1.B9

Board: 2 copper layers, 241.3 x 106.4 mm, 104 parts (0 on the bottom side), 68 nets.

## Commit log

2020-05-24 initial checkin
2020-05-24 Added Gerber files
2020-05-25 added reset button
2020-05-25 updated gerber with reset button
2020-05-25 revised images ton include reset button
2020-05-25 added schematic
2020-05-25 renamed KiCad project to reflect new keyboard name
2020-05-25 updated schematic
2020-05-25 updated schematic to close some tracks
2020-05-25 finished PCB and ran DRC with no errors
2020-05-25 Added new I2C Pin Header footprint
    I needed the I2C legend printed on the silkscreen layer, so I made a new footprint.
2020-05-25 Add MX submodules
2020-05-25 Add QMK Hardware submodule
2020-05-25 Updated schematic details and footprint references
2020-05-25 Updated schematic to use project symbols from submodules
2020-05-25 reworked back traces
2020-05-26 reworked front traces
2020-05-26 shrank the board size
2020-05-26 fixed unconnected diode
2020-05-26 reworked diodes so the board could be smaller
2020-05-26 Move Proton to bottom of board and made board smaller
2020-05-26 Added Proton Pinout diagram
2020-05-26 flipped Proton so it will be arranged correctly on the back of the board.
2020-05-26 Updated reame and fixed stray trace in PCB
2020-05-26 Reworked switches so that they lined up to the grid
2020-05-26 cleaned up PCB
2020-05-26 updated PCB and images
2020-05-27 rounded the edges of the board
2020-05-27 rounded the edges of the PCB
2020-05-27 modified gerber files
2020-05-27 fixed PCB outline
2020-05-27 Move proton (#2)
    * Move Proton to bottom of board and made board smaller
    * Added Proton Pinout diagram
    * flipped Proton so it will be arranged correctly on the back of the board.
    * Updated reame and fixed stray trace in PCB
    * Reworked switches so that they lined up to the grid
    * cleaned up PCB
2020-05-27 centered middle mounting hole
2020-05-27 reset switch number annotations
2020-05-27 adjusted outline so that standoffs would fit
2020-05-27 added extra mounting holes and a top and bottom plate
2020-05-27 updated images
2020-06-07 moved controller to the top of the board
